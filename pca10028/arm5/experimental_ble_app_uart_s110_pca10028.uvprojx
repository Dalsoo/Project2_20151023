# Keil uVision project experimental_ble_app_uart_s110_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10001 BOARD_PCA10028
  c misc: --c99
  c include: ..\..\user_App\src;..\..\user_App\inc;..\..\Max30101;C:\Keil_v5\ARM\Pack\NordicSemiconductor\nRF_Drivers\1.2.1\hal
  asm include: ..\..\Max30101
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../: ble_nus.c main.c
  group Documentation
    ../../: Abstract.txt license.txt
  group User_Program
    ../../user_App/src/: sys_i2c_driver.c sys_delay.c sys_uart.c sys_initialize.c sys_interrupt.c sys_ble_process.c sys_Gas_Battery.c sys_iAQ_sensor.c sys_dust_sensor.c SYS_TempHumiPress.c
    ../../user_App/inc/: nrf51.h sys_ble_process.h sys_i2c_driver.h sys_initialize.h sys_Main.h sys_uart.h sys_delay.h sys_iAQ_sensor.h sys_dust_sensor.h sys_TempHumiPress.h sys_Gas_Battery.h
software components: CMSIS:CORE , Board Support:bsp 7.2.0, Device:Startup 1.0.0, nRF_BLE:BLE_Modules:ble_advdata 1.1.1, nRF_BLE:BLE_Modules:ble_common 1.1.1, nRF_BLE:BLE_Modules:ble_conn_params 1.1.1, nRF_BLE:BLE_Modules:ble_service_common 1.1.1, nRF_Drivers:nrf_delay 1.2.1, nRF_Drivers:nrf_error 1.2.1, nRF_Drivers:nrf_gpio 1.2.1, nRF_Drivers:simple_uart 1.2.1, nRF_Libraries:app_button 1.1.1, nRF_Libraries:app_error 1.1.1, nRF_Libraries:app_gpiote 1.1.1, nRF_Libraries:app_scheduler 1.1.1, nRF_Libraries:app_timer 1.1.1, nRF_Libraries:app_util 1.1.1, nRF_Libraries:nrf_assert 1.1.1, nRF_SoftDevice:Internal:sd_common 1.1.1, nRF_SoftDevice:Internal:softdevice_present 1.1.1, nRF_SoftDevice:s110 7.1.0-3
